# IAR project LCD_Pixel_OnOff.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST; M256D
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\LCDLib\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD_Pixel_OnOff.srec
  ILINK.IlinkOutputFile: LCD_Pixel_OnOff.out
  ILINK.IlinkIcfFile: m251.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: M256D
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\LCDLib\Include
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c lcd.c retarget.c sys.c uart.c
    ../../../../Library/LCDLib/Source/: lcdlib.c
  group User
    ../: main.c
