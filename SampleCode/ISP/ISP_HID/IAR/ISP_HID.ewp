# IAR project ISP_HID.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISP_HID.bin
  ILINK.IlinkOutputFile: ISP_HID.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M251\Source\IAR\LDROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251_isp.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group User
    ../: descriptors.c fmc_user.c hid_transfer.c isp_user.c main.c targetdev.c usbd_user.c
