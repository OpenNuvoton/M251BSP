# Keil uVision project ISP_HID.uvprojx, settings and files
target ISP_HID (6220000::V6.22::ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: ISP_HID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c include: .\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M251\Source\ARM\LDROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251_isp.c
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group User
    ../: descriptors.c main.c hid_transfer.c fmc_user.c isp_user.c targetdev.c usbd_user.c
