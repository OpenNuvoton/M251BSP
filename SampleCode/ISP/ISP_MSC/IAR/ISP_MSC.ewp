# IAR project ISP_MSC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISP_MSC.bin
  ILINK.IlinkOutputFile: ISP_MSC.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M251\Source\IAR\LDROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251_isp.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group User
    ../: DataFlashProg.c descriptors.c main.c MassStorage.c usbd_User.c
