# Keil uVision project FMC_IAP_APROM.uvprojx, settings and files
target FMC_IAP_APROM (6120000::V6.12::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_IAP_APROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M251\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
  group User
    ./: ap_image.s
    ../: FMC_IAP_APROM.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c fmc.c
