# IAR project FMC_IAP_APROM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_IAP_APROM.bin
  ILINK.IlinkOutputFile: FMC_IAP_APROM.out
  ILINK.IlinkIcfFile: FMC_IAP_APROM.icf
  ILINK.IlinkExtraOptions: --image_input FMC_IAP_LDROM.bin,loaderImage1Base,.bin_image,4; --image_input dummy.end,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: FMC_IAP_APROM.c
