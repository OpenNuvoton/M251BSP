# Keil uVision project PSIO_LED.uvprojx, settings and files
target PSIO_LED (6070000::V6.7::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: PSIO_LED
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c misc: -fshort-enums -fshort-wchar
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\PSIO_LED
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M251\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c uart.c pdma.c
    ../: WS1812B_driver_LED.c
  group User
    ../: main.c
