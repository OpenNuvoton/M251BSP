# Keil uVision project BPWM_SyncStart.uvprojx, settings and files
target BPWM_SyncStart (6070000::V6.7::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: BPWM_SyncStart
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c bpwm.c
software components: CMSIS:CORE 5.0.1
