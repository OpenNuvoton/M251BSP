# IAR project QSPI_QuadMode_Flash.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 56
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M251\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: QSPI_QuadMode_Flash.bin
  ILINK.IlinkOutputFile: QSPI_QuadMode_Flash.out
  ILINK.IlinkIcfFile: m251.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c qspi.c retarget.c sys.c uart.c
  group User
    ../: main.c
