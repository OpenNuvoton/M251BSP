# Keil uVision project SYS_TrimHIRC.uvprojx, settings and files
target SYS_TrimHIRC (6100001::V6.10.1::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: SYS_TrimHIRC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c misc: -fshort-enums -fshort-wchar
  c include: ..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M251\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c
  group User
    ../: main.c
