# IAR project TIMER_PWM_OutputWaveform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 56
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\SmartcardLib\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_PWM_OutputWaveform.srec
  ILINK.IlinkOutputFile: TIMER_PWM_OutputWaveform.out
  ILINK.IlinkIcfFile: m251.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer_pwm.c uart.c
  group User
    ../: main.c
