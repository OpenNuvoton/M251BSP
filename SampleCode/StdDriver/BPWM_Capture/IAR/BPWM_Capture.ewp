# IAR project BPWM_Capture.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 56
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M251\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BPWM_Capture.bin
  ILINK.IlinkOutputFile: BPWM_Capture.out
  ILINK.IlinkIcfFile: m251.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../Library/StdDriver/src/: pwm.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/StdDriver/src/: bpwm.c clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
