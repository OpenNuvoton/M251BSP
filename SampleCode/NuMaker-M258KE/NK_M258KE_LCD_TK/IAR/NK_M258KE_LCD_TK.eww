<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NK_M258KE_LCD_TK.ewp</path>
  </project>
  <batchBuild/>
</workspace>


