# Keil uVision project NK_M258KE_LCD_TK.uvprojx, settings and files
target NK_M258KE_LCD_TK (6120000::V6.12::.\ARMCLANG)
  device: M258KE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: TK_FreeRun
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: DEMO_FREERUN
  c include: ..\..\TouchKey;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\TkLib;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\LCDLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/TkLib/: TKLib_Calibration.lib TKLib_FreeRun.lib TKLib_MassProduction.lib
  group Source
    ../: TK_DebugUART.c TK_Main.c TK_MultPinFunctions.c TK_SysTick.c TK_UartCmd.c TK_MassProduction.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c timer.c clk.c sys.c retarget.c gpio.c
  group Temperature
    ../: ADC_Vtemp.c
    ../../../../Library/StdDriver/src/: eadc.c
  group LCD
    ../../../../Library/StdDriver/src/: lcd.c
    ../: LCD_NK.c
    ../../../../Library/LCDLib/Source/: lcdlib.c
target TK_Calibration (6120000::V6.12::.\ARMCLANG)
  device: M258SD3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: as above
  output: TK_Calibration
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: DEMO_CALIBRATION,MASS_FINETUNE,DEBUG_PORT=UART1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
