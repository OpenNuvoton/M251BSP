# Keil uVision project TK_PowerDownMode.uvprojx, settings and files
target TK_PowerDownMode_FreeRun (6240000::V6.24::ARMCLANG)
  device: M258KE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: TK_PowerDownMode_FreeRun
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEMO_FREERUN,DEBUG_PORT=UART1,M258G
  c misc: -Wconditional-uninitialized
  c include: ..\..\TouchKey;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\TkLib\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\LCDLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\TK_FreeRun.scf
  group Startup
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    ../../../../Library/TkLib/: TKLib_Calibration.lib TKLib_FreeRun.lib TKLib_MassProduction.lib
  group Source
    ../: TK_DebugUART.c TK_Main.c TK_MultPinFunctions.c TK_SysTick.c TK_UartCmd.c TK_MassProduction.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c timer.c clk.c sys.c tk.c retarget.c gpio.c fmc.c
  group Inc
    ../: TK_Data.c
target TK_PowerDownMode_Calibration (6240000::V6.24::ARMCLANG)
  device: M258KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: TK_PowerDownMode_Calibration
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEMO_CALIBRATION,DEBUG_PORT=UART1
  c misc: -Wconditional-uninitialized
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\TK_Calibration.scf
