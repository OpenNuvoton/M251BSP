<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Level1_EADC_BandGapCalculateAVDD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


