# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (6240000::V6.24::ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: Blinky
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM23_NTZ\non_secure;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M251\Source\ARM\APROM.scf
  link misc: --pd="-DSRAM_SIZE=0x8000"
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
  group Libraries
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c
  group User
    ../: main.c main-blinky.c main-full.c ParTest_M251.c Reg_Test.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
    ../../../../ThirdParty/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group CommonDemo
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
